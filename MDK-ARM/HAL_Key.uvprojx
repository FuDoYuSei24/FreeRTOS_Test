# Keil uVision project HAL_Key.uvprojx, settings and files
target HAL_Key (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3") TZ
  output: HAL_Key +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103xE
  c include: ../Core/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F1xx/Include;../Drivers/CMSIS/Include;../Int;..\FreeRTOS\portable\RVDS\ARM_CM3;..\FreeRTOS\include;..\FreeRTOS\demo
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Application/MDK-ARM
    ./: startup_stm32f103xe.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c usart.c stm32f1xx_it.c stm32f1xx_hal_msp.c stm32f1xx_hal_timebase_tim.c
    ../Core/Inc/: FreeRTOSConfig.h
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_uart.c stm32f1xx_hal.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_dma.c stm32f1xx_hal_cortex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_exti.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f1xx.c
  group Int
    ../Int/: Key.c LED.c
  group FreeRTOS/Source
    ../FreeRTOS/source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
  group FreeRTOS/Portable
    ../FreeRTOS/portable/RVDS/ARM_CM3/: port.c
    ../FreeRTOS/portable/MemMang/: heap_4.c
  group FreeRTOS/Test
    ../FreeRTOS/demo/: FreeRTOS_Demo.c FreeRTOS_Demo.h
  group HARDWARE
    ../../FreeRTOS_基于stm32F407的简单门禁系统/HARDWARE/24CXX/: 24cxx.c 24cxx.h
    ../../FreeRTOS_基于stm32F407的简单门禁系统/HARDWARE/AS608/: as608.c as608.h
    ../../FreeRTOS_基于stm32F407的简单门禁系统/HARDWARE/BEEP/: beep.c beep.h
    ../../FreeRTOS_基于stm32F407的简单门禁系统/HARDWARE/IIC/: myiic.c myiic.h
    ../../FreeRTOS_基于stm32F407的简单门禁系统/HARDWARE/KEY/: key.c key.h
    ../../FreeRTOS_基于stm32F407的简单门禁系统/HARDWARE/LCD/: FONT.H lcd.c lcd.h
    ../../FreeRTOS_基于stm32F407的简单门禁系统/HARDWARE/LED/: led.c led.h
    ../../FreeRTOS_基于stm32F407的简单门禁系统/HARDWARE/PWM/: pwm.c pwm.h
    ../../FreeRTOS_基于stm32F407的简单门禁系统/HARDWARE/RC52/: RC52.c RC52.h
    ../../FreeRTOS_基于stm32F407的简单门禁系统/HARDWARE/TEXT/: fontupd.c fontupd.h text.c text.h
    ../../FreeRTOS_基于stm32F407的简单门禁系统/HARDWARE/tim/: bsp_basic_tim.c bsp_basic_tim.h
    ../../FreeRTOS_基于stm32F407的简单门禁系统/HARDWARE/TIMER/: timer.c timer.h
    ../../FreeRTOS_基于stm32F407的简单门禁系统/HARDWARE/TIMER7/: timer7.c timer7.h
    ../../FreeRTOS_基于stm32F407的简单门禁系统/HARDWARE/TOUCH/: ctiic.c ctiic.h ft5206.c ft5206.h gt9147.c gt9147.h ott2001a.c ott2001a.h touch.c touch.h
    ../../FreeRTOS_基于stm32F407的简单门禁系统/HARDWARE/USART2/: usart2.h usart2.c
    ../../FreeRTOS_基于stm32F407的简单门禁系统/HARDWARE/USART3/: usart3.c usart3.h
  group ESP8266
    ../../FreeRTOS_基于stm32F407的简单门禁系统/ESP8266/: esp8266.c esp8266.h
software components: CMSIS:CORE 4.3.0
